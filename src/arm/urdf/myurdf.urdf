Commit message: 3次元復元をできるようになった（精度は悪い）

File: src/arm/urdf/myurdf.urdf (robot description, URDF)
Before this commit: robot test_robot, 4 links, 3 joints
Links:
- removed link base_link
- added link map
Joints:
- joint body1_joint: parent base_link -> map
